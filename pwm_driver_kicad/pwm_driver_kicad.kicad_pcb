# Repository mjkloeckner/pwm_driver

File README.md:

# Pulse-width Modulation Driver

This is a simple [Pulse-width Modulation](https://en.wikipedia.org/wiki/Pulse-width_modulation) Driver that
can drive LED strips or other DC loads. The base schematic is taken from
[Creastive Creator's post](https://www.hackster.io/dhritimanhb2015/led-dimmer-circuit-with-555-timer-bc30f7) on [hackster.io](https://hackster.io).

## 3D Models used on the PCB

The majority of 3D Models used are from the official KiCAD 3D library. The ones
missing, which the KiCAD 3D library does not include are designed from scratch
using FreeCAD (located on `pwm_driver_kicad/pwm_driver_3d_models`). There's also
thrid-party 3D models which have much more detail, for example:

- [16mm Alpha Potentiometer](https://grabcad.com/library/alpha-rv16af-20-1)
- [Screw terminal DG-301 5mm](https://grabcad.com/library/screw-terminal-dg-301-5mm-1)

## Case

The case for the projects has been developed using FreeCAD.

### Considerations

- Fully parametric design: The majority of the values used in the design can be
  easily changed by modifying the contents of the `param` spreadsheet
- No threaded holes: Even tho FreeCAD offers an option to thread the holes,
  considering that the screws used have a diameter that is less than `3.5 mm`
  and the majority of 3D printers don't have that level of detail, I considered
  not doing the thread on holes and doing it later with the physical screw at
  the time of the build.

## Resources Consulted

This are some web resources that I consulted during the build

- [Electronics enclosure for 3D printing // FreeCAD + KiCAD complete
  walkthrough](https://www.youtube.com/watch?v=ov3PpaP9uHI)

## License

[MIT](https://opensource.org/licenses/MIT)

## KiCad design pwm_driver_kicad/pwm_driver_kicad.kicad_pcb

Board: 2 copper layers, 35.0 x 35.0 mm, 10 parts (0 on the bottom side), 9 nets.

Parts:
C1, C2: 10nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2: 4148; D_DO-34_SOD68_P7.62mm_Horizontal
J1: Bornera; TerminalBlock_Altech_AK300-3_P5.00mm
Q1: IRF540; TO-220-3_Vertical
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 50k; Potentiometer_Alps_RK163_Single_Horizontal
U1: NE555P; DIP-8_W7.62mm

Connections:
GND: C1.2, C2.2, J1.2, Q1.3 (S), R1.2, U1.1 (GND)
unnamed: D1.2 (A), D2.1 (K), R2.2, U1.7 (DIS)
unnamed: D1.1 (K), RV1.3
unnamed: D2.2 (A), RV1.1
unnamed: J1.1 (Pin_3), Q1.1 (D)
unnamed: Q1.2 (G), R1.1, U1.3 (Q)
unnamed: C1.1, U1.5 (CV)
unnamed: C2.1, RV1.2, U1.2 (TR), U1.6 (THR)
VCC: J1.3 (Pin_1), R2.1, U1.4 (R), U1.8 (VCC)

## Commit log

2024-02-29 First insertion
2024-02-29 Add README.md
2024-02-29 Change README.md picture
2024-02-29 Renamed driver_pwm -> pwm_driver
2024-02-29 Fix mispell in directory name
2024-02-29 Update README.md image
2024-02-29 Set correct 3d models path
2024-02-29 Add missing 3d models and simulation // Use rel. paths
2024-02-29 Added 3d models source
2024-02-29 Added license
2024-02-29 Update README.me image link
2024-03-02 pwm_driver FreeCAD 3d model
2024-03-02 pwm_driver Case .stl files
2024-03-21 Update LICENSE year
2024-11-02 update schematic resistor values | fix simulation
    NOTE: the pcb has **not** been updated yet
2024-11-02 update `README.md`
2024-11-02 add transistor gate pulldown resistor
2024-11-02 update pcb from schematic
2024-11-06 fix mosfet footprint pinout
2024-11-06 add IRF540 spice simulation model
2024-11-06 add led spice model: `pwm_driver_spice_simulation_models/led.lib`
2024-11-06 update pcb layout
2024-11-26 replace third party 3D potentiometer model with own design
2024-11-30 set all missing 3d models to self design
2024-11-30 add folder `informe/`
2024-11-30 add simulation csv files
2024-11-30 add exploded assembly to freecad project
2024-11-30 remove 3rd-party models; fix pcb new models path
2024-11-30 set case lid and pcb visible
2024-12-07 update `informe/`; move all images to `informe/img/`
2024-12-07 add exploded assembly video
2024-12-07 removed `informe.pdf` generation files
2024-12-09 update `informe.pdf`
2024-12-09 crop start and end from `pwm_driver_exploded_assembly.mkv`
